<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>_BSP</name>
    <group>
      <name>Include</name>
      <file>
        <name>$PROJ_DIR$\..\bsp\ant_integration.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\bsp\anttt-eief1-01.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\bsp\ble_integration.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\bsp\bleperipheral.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\bsp\configuration.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\bsp\interrupts.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\bsp\leds_anttt.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\bsp\soc_integration.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\bsp\utilities.h</name>
      </file>
    </group>
    <group>
      <name>Source</name>
      <file>
        <name>$PROJ_DIR$\..\bsp\ant_integration.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\bsp\anttt-eief1-01.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\bsp\ble_integration.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\bsp\bleperipheral.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\bsp\interrupts.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\bsp\leds_anttt.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\bsp\soc_integration.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\bsp\utilities.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>_Nordic_SDK_6_1_0</name>
    <group>
      <name>Include</name>
      <file>
        <name>$PROJ_DIR$\..\nordic_sdk6_1_0\Include\s310\ant_error.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\nordic_sdk6_1_0\Include\s310\ant_interface.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\nordic_sdk6_1_0\Include\s310\ant_parameters.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\nordic_sdk6_1_0\Include\s310\ble.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\nordic_sdk6_1_0\Include\ble\ble_advdata.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\nordic_sdk6_1_0\Include\ble\ble_advdata_parser.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\nordic_sdk6_1_0\Include\s310\ble_gap.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\nordic_sdk6_1_0\Include\s310\ble_gatts.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\nordic_sdk6_1_0\Include\s310\ble_types.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\nordic_sdk6_1_0\Include\nordic_common.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\nordic_sdk6_1_0\Include\nrf.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\nordic_sdk6_1_0\Include\nrf51.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\nordic_sdk6_1_0\Include\nrf_assert.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\nordic_sdk6_1_0\Include\nrf_delay.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\nordic_sdk6_1_0\Include\nrf_gpio.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\nordic_sdk6_1_0\Include\nrf_gpiote.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\nordic_sdk6_1_0\Include\s310\nrf_sdm.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\nordic_sdk6_1_0\Include\s310\nrf_soc.h</name>
      </file>
    </group>
    <group>
      <name>Source</name>
      <file>
        <name>$PROJ_DIR$\..\nordic_sdk6_1_0\ble_advdata.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\nordic_sdk6_1_0\ble_advdata_parser.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\nordic_sdk6_1_0\iar_startup_nrf51.s</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\nordic_sdk6_1_0\system_nrf51422.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>Application</name>
    <group>
      <name>Include</name>
      <file>
        <name>$PROJ_DIR$\..\application\anttt.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\application\bleperipheral_engenuics.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\application\main.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\application\typedefs.h</name>
      </file>
    </group>
    <group>
      <name>Source</name>
      <file>
        <name>$PROJ_DIR$\..\application\anttt.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\application\bleperipheral_engenuics.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\application\main.c</name>
      </file>
    </group>
  </group>
</project>


